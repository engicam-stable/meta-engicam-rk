
IMAGE_INSTALL_append = " \
		linux-firmware \
		kernel-modules \
		brcm-patchram-plus \
		lwb-bcm4343w-fw \
"