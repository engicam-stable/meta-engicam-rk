SRC_URI = " \
	git://${TOPDIR}/../../u-boot;protocol=file;usehead=1 \
"
SRCREV = "${AUTOREV}"
